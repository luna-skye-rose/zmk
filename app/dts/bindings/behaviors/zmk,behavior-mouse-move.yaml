## app/dts/bindings/behaviors/zmk,behavior-mouse-move.yaml
```yaml
description: Mouse key press/release behavior

compatible: "zmk,behavior-mouse-move"

include: one_param.yaml
```
